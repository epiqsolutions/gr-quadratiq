<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>bandwidthA</value></param>
<param><key>value</key><value>20000000</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>bandwidthB</value></param>
<param><key>value</key><value>20000000</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>freqA</value></param>
<param><key>value</key><value>880000000</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>freqB</value></param>
<param><key>value</key><value>751000000</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>gainA1</value></param>
<param><key>value</key><value>50</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>gainA2</value></param>
<param><key>value</key><value>50</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>gainB1</value></param>
<param><key>value</key><value>50</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>gainB2</value></param>
<param><key>value</key><value>50</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>sampleRateA</value></param>
<param><key>value</key><value>30000000</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>sampleRateB</value></param>
<param><key>value</key><value>25000000</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_interleaved_short_to_complex</key>
<param><key>id</key><value>blocks_interleaved_short_to_complex_0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_interleaved_short_to_complex</key>
<param><key>id</key><value>blocks_interleaved_short_to_complex_0_0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_interleaved_short_to_complex</key>
<param><key>id</key><value>blocks_interleaved_short_to_complex_0_1</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_interleaved_short_to_complex</key>
<param><key>id</key><value>blocks_interleaved_short_to_complex_0_2</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>channel_a</value></param>
<param><key>bw</key><value>sampleRateA</value></param>
<param><key>fc</key><value>freqA</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>label1</key><value>Rx1</value></param>
<param><key>label2</key><value>Rx2</value></param>
<param><key>name</key><value>"Chan A"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>50</value></param>
<param><key>ymin</key><value>-50</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>channel_b</value></param>
<param><key>bw</key><value>sampleRateB</value></param>
<param><key>fc</key><value>freqB</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>label1</key><value>Rx1</value></param>
<param><key>label2</key><value>Rx2</value></param>
<param><key>name</key><value>"Chan B"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>50</value></param>
<param><key>ymin</key><value>-50</value></param>
</block>
<block>
<key>quadratiq_qtiq_source_s</key>
<param><key>id</key><value>quadratiq_qtiq_source_s_0</value></param>
<param><key>bandwidthA</key><value>bandwidthA</value></param>
<param><key>freqA</key><value>freqA</value></param>
<param><key>sampleRateA</key><value>sampleRateA</value></param>
<param><key>bandwidthB</key><value>bandwidthB</value></param>
<param><key>freqB</key><value>freqB</value></param>
<param><key>sampleRateB</key><value>sampleRateB</value></param>
<param><key>ctrl_ip</key><value>192.168.2.246</value></param>
<param><key>ctrl_port</key><value>7737</value></param>
<param><key>gainA1</key><value>gainA1</value></param>
<param><key>gainA2</key><value>gainA2</value></param>
<param><key>gainB1</key><value>gainB1</value></param>
<param><key>gainB2</key><value>gainB2</value></param>
</block>
<connection><source_block_id>blocks_interleaved_short_to_complex_0</source_block_id><sink_block_id>channel_a</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_short_to_complex_0_0</source_block_id><sink_block_id>channel_a</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_interleaved_short_to_complex_0_1</source_block_id><sink_block_id>channel_b</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_short_to_complex_0_2</source_block_id><sink_block_id>channel_b</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>quadratiq_qtiq_source_s_0</source_block_id><sink_block_id>blocks_interleaved_short_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>quadratiq_qtiq_source_s_0</source_block_id><sink_block_id>blocks_interleaved_short_to_complex_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>quadratiq_qtiq_source_s_0</source_block_id><sink_block_id>blocks_interleaved_short_to_complex_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>quadratiq_qtiq_source_s_0</source_block_id><sink_block_id>blocks_interleaved_short_to_complex_0_2</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
</flow_graph>
